PACKAGECONFIG += " opengl gbm libinput "
PACKAGECONFIG:remove = " sysvinit systemd x11 xwayland "