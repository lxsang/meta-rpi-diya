SERIAL_CONSOLES_CHECK = ""
CURR_SERIAL_CONSOLES:="${SERIAL_CONSOLES}"
SERIAL_CONSOLES = "${@bb.utils.contains('RPI_USE_wS_28_DPI_LCD', '1', '', '${CURR_SERIAL_CONSOLES}', d)}"