core-image-minimal.bbappend