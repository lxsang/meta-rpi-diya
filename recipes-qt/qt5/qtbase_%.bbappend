PACKAGECONFIG += " freetype jpeg libpng kms openssl widgets gles2 eglfs udev "
PACKAGECONFIG:remove = " tests tools examples "