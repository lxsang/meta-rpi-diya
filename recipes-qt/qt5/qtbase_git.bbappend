PACKAGECONFIG += " freetype jpeg libpng kms openssl widgets gles2 eglfs optimize-size udev "
PACKAGECONFIG:remove = " tests tools examples "