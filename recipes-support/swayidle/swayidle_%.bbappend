PACKAGECONFIG:remove = " systemd sysvinit man-pages "