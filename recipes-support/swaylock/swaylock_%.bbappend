PACKAGECONFIG:remove = " man-pages pam "
