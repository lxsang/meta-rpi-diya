FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
 
# inherit kernel
SRC_URI += " \
    file://diya.cfg \
"