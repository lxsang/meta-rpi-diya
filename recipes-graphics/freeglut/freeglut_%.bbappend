PACKAGECONFIG += " gles "
PACKAGECONFIG:remove = " x11 wayland "
DEPENDS:remove = " libxi "